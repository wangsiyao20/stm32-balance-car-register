# Keil uVision project car_register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\02_arm5_compiler)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: car_register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\Start;.\User;.\Mid\FreeRTOS\include;.\Mid\FreeRTOS\portable;.\Mid\FreeRTOS;.\Dri;.\Inf;.\Dri\Usart;.\App;.\Com;.\Inf\Encoder;.\Inf\MPU6050;.\Com
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group User
    ./User/: main.c
  group Mid/FreeRTOS/source
    ./Mid/FreeRTOS/: FreeRTOSConfig.h
    ./Mid/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Mid/FreeRTOS/portable
    ./Mid/FreeRTOS/portable/: heap_4.c port.c
  group Dri
    ./Dri/: Dri_SPI.c Dri_TIM.c Dri_I2C.c
  group Inf
    ./Inf/: Inf_LED.c Inf_OLED1315.c Inf_TB6612.c
  group Dri/Usart
    ./Dri/Usart/: Driver_Usart.c
  group App
    ./App/: App_Task.c App_Car.c
  group Com
    ./Com/: Com_Filter.c
  group Inf/Encoder
    ./Inf/Encoder/: Int_Encoder.c
  group Inf/MPU6050
    ./Inf/MPU6050/: Inf_MPU6050.c
